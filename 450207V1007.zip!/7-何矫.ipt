# Autodesk Inventor part: 부시
## iProperties
Company: 한국ATC센터
Created: 2013-01
Part Number: 부시
Document SubType Name: Modeling
Designer: KYOUNG IL JANG
Density: 1 g/cm^3
Author: KYOUNG IL JANG
