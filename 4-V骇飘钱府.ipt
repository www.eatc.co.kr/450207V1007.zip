# Autodesk Inventor part: V벨트풀리
## iProperties
Created: 2015-02
Part Number: V벨트풀리
Document SubType Name: Modeling
Designer: KYOUNG IL JANG
Density: 1 g/cm^3
Company: 한국ATC센터
Author: KYOUNG IL JANG
