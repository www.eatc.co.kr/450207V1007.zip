# Autodesk Inventor part: 축
## iProperties
Company: 한국ATC센터
Created: 2015-02
Part Number: 축
Document SubType Name: Modeling
Designer: KYOUNG IL JANG
Density: 1 g/cm^3
Author: KYOUNG IL JANG
