# Autodesk Inventor part: 커버
## iProperties
Company: 한국ATC센터
Created: 2013-01
Part Number: 커버
Document SubType Name: Modeling
Designer: KYOUNG IL JANG
Density: 1 g/cm^3
Author: KYOUNG IL JANG
